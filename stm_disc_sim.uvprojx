# Keil uVision project stm_disc_sim.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm_disc_sim +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: main.c
  group info
    ./: readme.txt
software components: CMSIS:CORE 5.0.0, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DAC 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:Startup 2.6.0
